# Keil uVision project NRF.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NRF +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  c include: ..\..\MCAL\RCC\inc;..\..\MCAL\GPIO\inc;..\..\MCAL\SPI\inc;..\..\HAL\NRF24L01\INCLUDES;..\..\OTHERS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
    ../../MCAL/RCC/inc/: RCC_configuration.h RCC_interface.h RCC_private.h
    ../../MCAL/RCC/src/: RCC_program.c
    ../../MCAL/SPI/inc/: SPI.h SPI_cfg.h SPI_prv.h
    ../../MCAL/SPI/src/: SPI.c
    ../../MCAL/GPIO/inc/: DIO_config.h DIO_interface.h DIO_private.h
    ../../MCAL/GPIO/src/: DIO_PROGRAM.c
    ../../HAL/NRF24L01/INCLUDES/: nrf24l01.h nrf24l01_cfg.h nrf24l01_prv.h
    ../../HAL/NRF24L01/SOURCE/: nrf24l01.c
    ../../OTHERS/: common_macros.h std_types.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
