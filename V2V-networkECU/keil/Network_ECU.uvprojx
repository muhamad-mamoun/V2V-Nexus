# Keil uVision project Network_ECU.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Network_ECU
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ..\OTHERS;..\MCAL\CAN\Include;..\MCAL\GPIO\inc;..\MCAL\RCC\inc;..\MCAL\SPI\inc;..\HAL\NRF24L01\INCLUDES
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ../OTHERS/: common_macros.h std_types.h
    ../MCAL/SPI/inc/: SPI.h SPI_cfg.h SPI_prv.h
    ../MCAL/SPI/src/: SPI.c
    ../MCAL/RCC/src/: RCC_program.c
    ../MCAL/RCC/inc/: RCC_configuration.h RCC_interface.h RCC_private.h
    ../MCAL/GPIO/src/: DIO_PROGRAM.c
    ../MCAL/GPIO/inc/: DIO_config.h DIO_interface.h DIO_private.h
    ../APP/: V2V-networkECU.c
    ../HAL/NRF24L01/SOURCE/: nrf24l01.c
    ../HAL/NRF24L01/INCLUDES/: nrf24l01.h nrf24l01_cfg.h nrf24l01_prv.h
    ./: main.c
    ../MCAL/CAN/: Can.c Can.h Can_Cfg.h Can_Prv.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
