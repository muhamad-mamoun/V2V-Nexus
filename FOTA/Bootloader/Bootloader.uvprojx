# Keil uVision project Bootloader.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c include: .\OTHERS;.\MCAL\FPEC\INCLUDES;.\MCAL\GPIO\INCLUDES;.\MCAL\NVIC\INCLUDES;.\MCAL\RCC\INCLUDES;.\MCAL\SYSTICK\INCLUDES;.\MCAL\USART\INCLUDES
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\Linker Script\STM32F303RETX_FLASH.ld
  group Source Group 1
    ./OTHERS/: common_macros.h std_types.h
    ./MCAL/FPEC/SOURCE/: FPEC_program.c
    ./MCAL/FPEC/INCLUDES/: FPEC_config.h FPEC_interface.h FPEC_private.h
    ./MCAL/GPIO/SOURCE/: gpio.c
    ./MCAL/GPIO/INCLUDES/: gpio.h gpio_cfg.h gpio_prv.h
    ./MCAL/NVIC/SOURCE/: NVIC.c
    ./MCAL/NVIC/INCLUDES/: NVIC.h NVIC_Config.h NVIC_Prev.h
    ./MCAL/RCC/SOURCE/: RCC.c
    ./MCAL/RCC/INCLUDES/: RCC.h RCC_prv.h
    ./MCAL/SYSTICK/SOURCE/: STK_program.c
    ./MCAL/SYSTICK/INCLUDES/: STK_config.h STK_interface.h STK_private.h
    ./MCAL/USART/SOURCE/: USART.c
    ./MCAL/USART/INCLUDES/: UART_cfg.h UART_interface.h UART_private.h
    ./APP/: main.c Parse.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.11.3
