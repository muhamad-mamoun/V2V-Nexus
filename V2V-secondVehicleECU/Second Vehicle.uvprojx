# Keil uVision project Second Vehicle.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Second Vehicle
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\OTHERS;.\MCAL\GPIO\INCLUDES;.\MCAL\GPIO\SOURCE;.\MCAL\NVIC\INCLUDES;.\MCAL\NVIC\SOURCE;.\MCAL\PWM\INCLUDES;.\MCAL\PWM\SOURCE;.\MCAL\RCC\INCLUDES;.\MCAL\RCC\SOURCE;.\MCAL\SPI\INCLUDES;.\MCAL\SPI\SOURCE;.\MCAL\UART\INCLUDES;.\MCAL\UART\SOURCE;.\HAL\BLUETOOTH\INCLUDES;.\HAL\BLUETOOTH\SOURCE;.\HAL\MOTOR\INCLUDES;.\HAL\MOTOR\SOURCE;.\HAL\NRF24L01\INCLUDES;.\HAL\NRF24L01\SOURCE
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./OTHERS/: common_macros.h std_types.h
    ./MCAL/GPIO/SOURCE/: DIO_PROGRAM.c
    ./MCAL/GPIO/INCLUDES/: DIO_config.h DIO_interface.h DIO_private.h
    ./MCAL/NVIC/SOURCE/: NVIC_program.c
    ./MCAL/NVIC/INCLUDES/: NVIC_config.h NVIC_interface.h NVIC_private.h
    ./MCAL/PWM/SOURCE/: PWM_program.c
    ./MCAL/PWM/INCLUDES/: PWM_config.h PWM_interface.h PWM_private.h
    ./MCAL/RCC/SOURCE/: RCC_program.c
    ./MCAL/RCC/INCLUDES/: RCC_configuration.h RCC_interface.h RCC_private.h
    ./MCAL/SPI/SOURCE/: SPI.c
    ./MCAL/SPI/INCLUDES/: SPI.h SPI_cfg.h SPI_prv.h
    ./MCAL/UART/SOURCE/: USART_program.c
    ./MCAL/UART/INCLUDES/: USART_config.h USART_interface.h USART_private.h
    ./HAL/BLUETOOTH/SOURCE/: BLE.c
    ./HAL/BLUETOOTH/INCLUDES/: BLE.h BLE_Cfg.h BLE_Prv.h
    ./HAL/MOTOR/SOURCE/: motor.c
    ./HAL/MOTOR/INCLUDES/: motor.h motor_cfg.h motor_prv.h
    ./HAL/NRF24L01/SOURCE/: nrf24l01.c
    ./HAL/NRF24L01/INCLUDES/: nrf24l01.h nrf24l01_cfg.h nrf24l01_prv.h
    ./APP/: V2V-secondVehicle.c
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS:FreeRTOS 10.5.1, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:Startup 1.0.0
