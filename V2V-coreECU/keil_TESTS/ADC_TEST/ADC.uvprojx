# Keil uVision project ADC.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ADC
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  c include: ..\..\MCAL\GPIO\INCLUDES;..\..\MCAL\RCC\inc;..\..\OTHERS;..\..\MCAL\ADC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c
    ../../MCAL/GPIO/SOURCE/: gpio.c
    ../../MCAL/GPIO/INCLUDES/: gpio.h gpio_cfg.h gpio_prv.h
    ../../MCAL/RCC/inc/: RCC.h RCC_prv.h
    ../../MCAL/RCC/src/: RCC.c
    ../../MCAL/ADC/: ADC.c ADC.h ADC_cfg.h ADC_prv.h
    ../../OTHERS/: common_macros.h std_types.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.11.3
