# Keil uVision project V2V_APP.uvprojx, settings and files
target Target 1 (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: V2V_APP +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=4
  c include: ..\OTHERS;..\MCAL\RCC\inc;..\MCAL\GPIO\INCLUDES;..\MCAL\NVIC Driver\Includes;..\MCAL\PWM\includes;..\MCAL\UART\Includes;..\MCAL\ICU\INCLUDES;..\MCAL\EXTI\Inludes;..\HAL\MOTOR\INCLUDES;..\HAL\Bluetooth\Includes;..\HAL\US\Includes;..\MCAL\CAN\Include;..\MCAL\I2C\inc;..\HAL\EEPROM\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c
    ../OTHERS/: common_macros.h std_types.h
    ../MCAL/RCC/inc/: RCC.h RCC_prv.h
    ../MCAL/RCC/src/: RCC.c
    ../MCAL/GPIO/INCLUDES/: gpio.h gpio_cfg.h gpio_prv.h
    ../MCAL/GPIO/SOURCE/: gpio.c
    ../MCAL/NVIC Driver/Srcs/: NVIC.c
    ../MCAL/NVIC Driver/Includes/: NVIC.h NVIC_Config.h NVIC_Prev.h
    ../MCAL/PWM/sources/: PWM.c
    ../MCAL/PWM/includes/: PWM.h PWM_cfg.h PWM_prv.h
    ../MCAL/UART/Includes/: UART_cfg.h UART_interface.h UART_private.h
    ../MCAL/UART/Srcs/: USART.c
    ../MCAL/ICU/INCLUDES/: ICU.h ICU_cfg.h ICU_prv.h
    ../MCAL/ICU/SOURCES/: ICU.c
    ../MCAL/EXTI/Inludes/: EXTI.h EXTI_Config.h EXTI_Prev.h
    ../MCAL/EXTI/Srcs/: EXTI.c EXTI_IRQ.c
    ../HAL/MOTOR/INCLUDES/: motor.h motor_cfg.h motor_prv.h
    ../HAL/MOTOR/SOURCE/: motor.c
    ../HAL/US/Includes/: US.h
    ../HAL/US/sources/: US.c
    ../HAL/Bluetooth/Includes/: BLE.h BLE_Cfg.h BLE_Prv.h
    ../HAL/Bluetooth/Srcs/: BLE.c
    ../MCAL/CAN/Include/: Can.h Can_Cfg.h Can_Prv.h
    ../MCAL/CAN/Srcs/: Can.c
    ../HAL/EEPROM/inc/: eeprom.h
    ../HAL/EEPROM/src/: eeprom.c
    ../MCAL/I2C/inc/: I2C.h I2C_prv.h
    ../MCAL/I2C/src/: I2C.c
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Event Groups 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 5.6.0, CMSIS:RTOS2:FreeRTOS 10.5.1, Device:Startup 1.11.3
