# Keil uVision project CAN.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CAN
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: Can.c Can.h Can_Cfg.h Can_Prv.h bit_math.h std_types.h main.c gpio.c gpio.h gpio_cfg.h gpio_prv.h RCC.c RCC.h RCC_prv.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.11.3
